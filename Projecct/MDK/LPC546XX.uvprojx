# Keil uVision project LPC546XX.uvprojx, settings and files
target SeekFree_LPC546XX (ARM-ADS)
  device: LPC54606J512BD208:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LPC546XX
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\USER\inc;..\USER\src;..\..\Libraries\startup\CoreSupport;..\..\Libraries\startup\DeviceSupport\MDK-ARM;..\..\Libraries\startup\DeviceSupport;..\..\Libraries\drives\inc;..\..\Libraries\drives\src;..\..\Libraries\seekfree;..\..\Libraries\drives\common;..\CODE;..\..\Rtt\include;..\..\Rtt\src;..\..\Rtt\libcpu\arm\cortex-m4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  group startup
    ../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_LPC54606.s
    ../../Libraries/startup/DeviceSupport/: system_LPC54606.c system_LPC54606.h
  group drives_h
    ../../Libraries/drives/inc/: LPC546XX_adc.h LPC546XX_ctimer.h LPC546XX_dma.h LPC546XX_eeprom.h LPC546XX_flexcomm.h LPC546XX_gint.h LPC546XX_gpio.h LPC546XX_iic.h LPC546XX_iocon.h LPC546XX_pint.h LPC546XX_pit.h LPC546XX_pll.h LPC546XX_sct.h LPC546XX_spi.h LPC546XX_systick.h LPC546XX_uart.h LPC546XX_mrt.h
  group drives_c
    ../../Libraries/drives/src/: LPC546XX_adc.c LPC546XX_ctimer.c LPC546XX_dma.c LPC546XX_eeprom.c LPC546XX_flexcomm.c LPC546XX_gint.c LPC546XX_gpio.c LPC546XX_iic.c LPC546XX_iocon.c LPC546XX_pint.c LPC546XX_pit.c LPC546XX_pll.c LPC546XX_sct.c LPC546XX_spi.c LPC546XX_systick.c LPC546XX_uart.c LPC546XX_mrt.c
  group common
    ../../Libraries/drives/common/: common.c common.h assert.c assert.h misc.c misc.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
  group user_h
    ../../Libraries/drives/inc/: headfile.h
    ../USER/inc/: isr.h LPC546XX_config.h
  group user_c
    ../USER/src/: isr.c main.c
  group seekfree
    ../../Libraries/seekfree/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h
  group rt_include
    ../../Rtt/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtm.h rtservice.h rtthread.h rtconfig.h RTE_Components.h
  group rt_libcpu
    ../../Rtt/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group rt_src
    ../../Rtt/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c board.c
